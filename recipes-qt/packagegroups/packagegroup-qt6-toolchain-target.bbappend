RDEPENDS_${PN}_remove = " \
    qtcharts-dev \
"
